<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gr_data</value></param>
<param><key>author</key><value>Ronny Milléo</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Dataset Generator</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>BPSK</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>PSK8</value></param>
<param><key>type</key><value>8psk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>QAM16</value></param>
<param><key>type</key><value>16qam</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>QPSK</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SNR_index</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SNR_linear</value></param>
<param><key>value</key><value>[100,63.0957,39.8107,25.1189,15.8489,10,6.3096,3.9811,2.5119,1.5849,1,0.6310,0.3981,0.2512,0.1585,0.1,0.0631,0.0398,0.0251,0.0158,0.01]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>delays</value></param>
<param><key>value</key><value>[0.0, 0.9, 1.7]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fD</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mags</value></param>
<param><key>value</key><value>[1.0, 0.8, 0.3]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_per_symbol</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>SNR_linear[SNR_index] + 1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_1</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1024*100*3</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>C:\Users\ronny\PycharmProjects\amcpy\gr-data\binary_PSK8(-16)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_dynamic_channel_model</key>
<param><key>id</key><value>channels_dynamic_channel_model_0</value></param>
<param><key>cfo_stdev</key><value>0.01</value></param>
<param><key>LOS</key><value>False</value></param>
<param><key>cfo_maxdev</key><value>1e3</value></param>
<param><key>fD</key><value>fD</value></param>
<param><key>sro_maxdev</key><value>1e3</value></param>
<param><key>N</key><value>8</value></param>
<param><key>ntaps</key><value>8</value></param>
<param><key>delays</key><value>0.0,0.1,1.3</value></param>
<param><key>mags</key><value>1,0.99,0.97</value></param>
<param><key>sro_stdev</key><value>0.01</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>noise_amp</key><value>SNR_linear[SNR_index]</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>constellation</key><value>PSK8</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>samples_per_symbol</key><value>samples_per_symbol</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_random_source_x_1</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_dynamic_channel_model_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>channels_dynamic_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
